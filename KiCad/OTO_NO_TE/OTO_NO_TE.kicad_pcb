# Repository yamamo2shun1/JUMBLEQ

File README.md:

# JUMBLEQ
“JUMBLEQ” is short for “jumbled equipment”

## Audio Spec.
- Analog: 4in/4out
- USB: 4in/4out(USB Audio Class 2.0) and MIDI in/out
- Format: 24bit, 48kHz/96kHz

## Electronic Spec.
- MCU: [STM32H7S3Z8](https://www.st.com/en/microcontrollers-microprocessors/stm32h7s3z8.html)
- DSP: [ADAU1466](https://www.analog.com/jp/products/adau1466.html)
- CODEC: [AK4619](https://www.akm.com/jp/ja/products/audio/audio-codec/ak4619vn/)
- IO: [Gateron Low Profile Magnet Jade Pro](https://www.gateron.com/products/gateron-full-pom-low-profile-magnetic-jade-pro-switch-set?srsltid=AfmBOopFkdCLZGMJNqQ-K2jzlEZM16yoIFbTWwkXe4nwWVk6TughK0Un&VariantsId=10870) x6 and Pot x8

## for Windows User
I’m developing JUMBLEQ as a solo project. I can’t realistically develop both an ASIO driver and the necessary firmware support on my own. If you’re using this device on Windows, please use [ASIO4ALL](https://asio4all.org/)—even if you’d prefer a dedicated ASIO driver.

## Firmware Update
JUMBLEQ uses a UF2 bootloader.
When you connect the USB cable while holding down SW3, it is recognized as a USB flash drive, so you can update the firmware simply by copying app.uf2—created using the procedure below—to the drive.
```
> arm-none-eabi-objcopy -O binary JUMBLEQ_Appli.elf app.bin
> python uf2conv.py -c -b 0x90010000 -f STM32H7RS -o app.uf2 app.bin
```

## Block Diagram

## Pinout (main board rev.C)

## Modules
- Original  
[AK4619 Audio Module](https://github.com/YamamotoWorksDev/AK4619_Module)  
Magnetic Switch & POT Module

- Third party  
[0.96インチ 128×64ドット有機ELディスプレイ(OLED) 白色](https://akizukidenshi.com/catalog/g/g112031/)  
[SparkFun Qwiic OLED Display (0.91 in., 128x32)](https://www.sparkfun.com/sparkfun-qwiic-oled-display-0-91-in-128x32-lcd-24606.html)  
[SparkFun Qwiic EEPROM Breakout - 512Kbit](https://www.sparkfun.com/sparkfun-qwiic-eeprom-breakout-512kbit.html)

## Byte Options

## KiCad design KiCad/OTO_NO_TE/OTO_NO_TE.kicad_pcb

Board: 4 copper layers, 114.3 x 85.0 mm, 77 parts (42 on the bottom side), 39 nets.

Parts:
C1: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5, C6, C7, C25, C27, C29, C31: 10nF; C_0402_1005Metric
C8, C9, C10, C11, C12, C13, C24, C26, C28, C30: C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: 100nF; C_0402_1005Metric
ICLED1, ICLED2, ICLED3, ICLED4, ICLED5, ICLED6, ICLED7, ICLED8, ICLED9, ICLED10: 1312020030000
J1, J2, J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10, RV11, RV12: 10k; RK09K1130A5R
U1, U2, U3, U4, U5, U6, U7, U9, U10, U11: DRV5056A3QDBZR; SOT-23
U8: CD74HC4067M; SOIC-24W_7.5x15.4mm_P1.27mm

Connections:
/KEY0: C8.1, J2.1, R1.2, U2.2 (OUT)
/KEY1: C9.1, J2.2, R2.2, U3.2 (OUT)
/KEY2: C10.1, J2.3, R3.2, U4.2 (OUT)
/KEY3: C11.1, J2.4, R4.2, U5.2 (OUT)
/KEY4: C12.1, J2.5, R5.2, U6.2 (OUT)
/KEY5: C13.1, J2.6, R6.2, U7.2 (OUT)
/KEY6: C24.1, R7.2, U1.2 (OUT), U8.19 (I12)
/KEY7: C26.1, R8.2, U8.18 (I13), U9.2 (OUT)
/KEY8: C28.1, R9.2, U8.17 (I14), U10.2 (OUT)
/KEY9: C30.1, R10.2, U8.16 (I15), U11.2 (OUT)
/L0: RV1.2, U8.9 (I0)
/L1: RV3.2, U8.8 (I1)
/L2: RV5.2, U8.7 (I2)
/L3: RV7.2, U8.6 (I3)
/L4: RV9.2, U8.5 (I4)
/L5: RV10.2, U8.4 (I5)
/LEDs/DIN: ICLED1.3 (DIN), J3.5
/R0: RV2.2, U8.3 (I6)
/R1: RV4.2, U8.2 (I7)
/R2: RV6.2, U8.23 (I8)
/R3: RV8.2, U8.22 (I9)
/R4: RV11.2, U8.21 (I10)
/R5: RV12.2, U8.20 (I11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, ICLED1.4 (VSS), ICLED2.4 (VSS), ICLED3.4 (VSS), ICLED4.4 (VSS), ICLED5.4 (VSS), ICLED6.4 (VSS), ICLED7.4 (VSS), ICLED8.4 (VSS), ICLED9.4 (VSS), ICLED10.4 (VSS), J3.6, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, RV11.1, RV12.1, U1.3 (GND), U2.3 (GND), U3.3 (GND), U4.3 (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND), U8.12 (GND), U8.15 (~E), U9.3 (GND), U10.3 (GND), U11.3 (GND)
unnamed: ICLED1.1 (DOUT), ICLED2.3 (DIN)
unnamed: ICLED2.1 (DOUT), ICLED3.3 (DIN)
unnamed: ICLED3.1 (DOUT), ICLED4.3 (DIN)
unnamed: ICLED4.1 (DOUT), ICLED5.3 (DIN)
unnamed: ICLED5.1 (DOUT), ICLED6.3 (DIN)
unnamed: ICLED6.1 (DOUT), ICLED7.3 (DIN)
unnamed: ICLED7.1 (DOUT), ICLED8.3 (DIN)
unnamed: ICLED8.1 (DOUT), ICLED9.3 (DIN)
unnamed: ICLED9.1 (DOUT), ICLED10.3 (DIN)
unnamed: J1.2, U8.10 (S0)
unnamed: J1.3, U8.11 (S1)
unnamed: J1.4, U8.14 (S2)
unnamed: J1.5, U8.13 (S3)
unnamed: J1.6, U8.1 (COM)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C25.1, C27.1, C29.1, C31.1, ICLED1.2 (VDD), ICLED2.2 (VDD), ICLED3.2 (VDD), ICLED4.2 (VDD), ICLED5.2 (VDD), ICLED6.2 (VDD), ICLED7.2 (VDD), ICLED8.2 (VDD), ICLED9.2 (VDD), ICLED10.2 (VDD), J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, RV11.3, RV12.3, U1.1 (VCC), U2.1 (VCC), U3.1 (VCC), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC), U7.1 (VCC), U8.24 (VCC), U9.1 (VCC), U10.1 (VCC), U11.1 (VCC)

File KiCad/OTO_NO_TE/jlcpcb/production_files/BOM-OTO_NO_TE.csv:

Comment,Designator,Footprint,LCSC,Quantity
100nF,C1,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C161117,1
10k,"RV1,RV10,RV11,RV12,RV2,RV3,RV4,RV5,RV6,RV7,RV8,RV9",RK09K1130A5R,C209779,12
DRV5056A3QDBZR,"U1,U10,U11,U2,U3,U4,U5,U6,U7,U9",SOT-23,C2866615,10
CD74HC4067M,U8,SOIC-24W_7.5x15.4mm_P1.27mm,C496123,1
10nF,"C2,C25,C27,C29,C3,C31,C4,C5,C6,C7",C_0402_1005Metric,C77019,10
100nF,"C14,C15,C16,C17,C18,C19,C20,C21,C22,C23",C_0402_1005Metric,C77020,10
Conn_01x06,J1,PinHeader_1x06_P2.54mm_Vertical,,1
~,R4,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C13,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,R5,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,R1,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C9,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,C10,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,C11,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C12,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R2,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,ICLED7,1312020030000,,1
~,ICLED10,1312020030000,,1
~,ICLED8,1312020030000,,1
~,ICLED5,1312020030000,,1
~,ICLED4,1312020030000,,1
~,ICLED2,1312020030000,,1
~,ICLED1,1312020030000,,1
~,ICLED3,1312020030000,,1
~,ICLED6,1312020030000,,1
~,ICLED9,1312020030000,,1
~,R10,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,R9,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C30,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,C28,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
Conn_01x06,J3,PinHeader_1x06_P2.54mm_Vertical,,1
Conn_01x06,J2,PinHeader_1x06_P2.54mm_Vertical,,1
~,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C26,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1
~,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
~,C24,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,,1

## KiCad design KiCad/OTO_NO_ITA/OTO_NO_ITA.kicad_pcb

Board: 6 copper layers, 73.0 x 72.0 mm, 130 parts (0 on the bottom side), 135 nets.

Parts:
C1, C22: 1uF; C_0402_1005Metric
C2, C5, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C19, C23, C26, C27, C28, C29, C31, C34, C37, C38, C41, C42, C43, C45, C48, C50, C52, C54, C56, C57, C58, C59, C71: 100nF; C_0201_0603Metric
C3, C18, C20, C24, C30: 4.7uF; C_0402_1005Metric
C4, C21, C25, C61: 100nF; C_0402_1005Metric
C32, C33, C35, C36: 2.2uF; C_0402_1005Metric
C39: 5.6nF; C_0201_0603Metric
C40: 150pF; C_0201_0603Metric
C44, C46, C55, C60: 10uF; C_0402_1005Metric
C47, C49, C51, C53: 10nF; C_0201_0603Metric
C62, C63, C64: 4.7uF; C_0603_1608Metric
C65, C66, C67: 1uF; C_0603_1608Metric
C68: 2.2uF/50V; C_0603_1608Metric
C69, C70: 560pF; C_0201_0603Metric
D1, D2, D3, D4, D7: LED; LED_0603_1608Metric
D5: D_Schottky; D_PowerDI-123
D6: D_Schottky; D_SOD-523
J1: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J2: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
J3: Conn_02x13_Odd_Even; PinSocket_2x13_P2.54mm_Vertical
J4: 15910060; PinHeader_2x03_P2.54mm_Vertical
J5: Conn_02x07_Odd_Even; PinSocket_2x07_P2.54mm_Vertical
J6: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J7, J8: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J9: UB1611-HGN; Gangyuan_UB1611-HGN
Q1: STD2805T4; TO-252-2
Q2, Q3: STL40DN3LLH5; SON_DN3LLH5_STM
R1, R2, R3, R11, R22, R24, R25: 10k; R_0201_0603Metric
R4, R9, R13, R14, R15, R16, R18, R19, R20: 33R; R_0201_0603Metric
R5, R6, R7, R8, R10, R26: 1k; R_0201_0603Metric
R12: 4.32k; R_0201_0603Metric
R17: 100k; R_0201_0603Metric
R21: 22mR; R_0603_1608Metric
R23: 2k4; R_0201_0603Metric
SW1, SW2, SW3, SW4: SKRPABE010
U1: MX25UW25645GXDI00; BGA24C100P5X5_800X600X120
U2: STM32H7S3Z8Tx; LQFP-144_20x20mm_P0.5mm
U3: ADAU1466WBCPZ300RL; CP_72_6_ADI
U4: ADM811TARTZ; SOT-143
U5: AP7361EA-33E-13; SOT-223-3_TabPin2
U6: AP2127N-1.8TRG1; SOT-23
U7: TCPP03-M20; QFN-20L_4.0X4.0X0.75_STM
U8: ESDA25P35-1U1M; QFN1610_STM
U9: ECMF2-40A100N6; QFN6L_ECMF2_STM
X1: 24MHz; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm
X2: 12.288MHz; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm

Connections:
1V8: C3.2, C4.2, C20.2, C21.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C66.1, C67.1, R2.2, R3.1, U1.B4 (VCC), U1.D1 (VCCQ), U1.E4 (VCCQ), U2.45 (VDDXSPI1), U2.51 (VDDXSPI1), U2.57 (VDDXSPI1), U2.63 (VDDXSPI1), U6.2 (VO)
3V3: C1.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C22.2, C23.2, C31.2, C34.2, C39.2, C40.1, C41.1, C43.1, C44.1, C45.1, C46.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.2, C63.1, C64.1, J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.1, J5.1, J5.2, Q1.3 (E), R5.1, R10.1, R25.2, U2.3 (VBAT), U2.7 (VDD), U2.17 (VDD), U2.24 (VREFP), U2.25 (VDDA), U2.31 (VDD), U2.41 (VDD), U2.69 (VDD), U2.81 (VDD), U2.88 (VDD), U2.100 (VDD), U2.108 (VDD), U2.115 (VDD50USB), U2.116 (VDD33USB), U2.123 (VDD), U2.133 (VDD), U2.139 (VDD), U3.2 (IOVDD), U3.7 (AVDD), U3.15 (PVDD), U3.18 (IOVDD), U3.38 (IOVDD), U3.56 (IOVDD), U4.4 (VCC), U5.3 (VO), U7.2 (VCC_VCONN), X1.4 (Vcc), X2.4 (Vcc)
5V: D5.1 (K), Q3.5 (D1), Q3.6 (D1)
5V_UCPD: C62.1, C65.1, J8.1, Q2.5 (D1), Q2.6 (D1), U5.1 (VI), U6.3 (VI)
/DSP/BCLK_OUT1: J5.6, U3.43 (BCLK_OUT1)
/DSP/BCLK_OUT2: J5.5, U3.48 (BCLK_OUT2)
/DSP/CLKOUT: J5.3, J5.4, R9.2, U2.87 (PC9)
/DSP/DSP_BCLK_IN0: R13.1, U2.72 (PD13)
/DSP/DSP_BCLK_OUT0: R14.1, U2.11 (PE5)
/DSP/DSP_LRCLK_IN0: R15.1, U2.71 (PD12)
/DSP/DSP_LRCLK_OUT0: R16.1, U2.10 (PE4)
/DSP/DSP_RESET: C42.1, SW4.1, SW4.2, U2.14 (PH1), U4.3 (~MR)
/DSP/DSP_SDATA_IN0: R18.1, U2.68 (PD11)
/DSP/DSP_SDATA_OUT0: R19.1, U2.12 (PE6)
/DSP/LRCLK_OUT1: J5.8, U3.42 (LRCLK_OUT1/MP5)
/DSP/LRCLK_OUT2: J5.7, U3.47 (LRCLK_OUT2/MP8)
/DSP/MCLK: R20.2, U3.21 (XTALIN/MCLK)
/DSP/SDATA_IN1: J5.12, U3.62 (SDATA_IN1)
/DSP/SDATA_IN2: J5.11, U3.67 (SDATA_IN2)
/DSP/SDATA_OUT1: J5.10, U3.44 (SDATA_OUT1)
/DSP/SDATA_OUT2: J5.9, U3.49 (SDATA_OUT2)
/DSP/USBi_MISO: J6.3, U2.126 (PM14), U3.30 (MISO/SDA)
/DSP/USBi_MOSI: J6.6, U2.127 (PM13), U3.32 (MOSI/ADDR1)
/DSP/USBi_SCLK: J6.5, U2.125 (PM11), U3.31 (SCLKC/SCL)
/DSP/USBi_SS: J6.7, R25.1, U2.124 (PM12), U3.33 (SS/ADDR0)
/DSP/~RESET: R17.2, U3.24 (RESET*), U4.2 (~RESET)
/MCU/ADC1_IN0: J1.4, U2.26 (PA0)
/MCU/ADC1_IN3: J1.3, U2.34 (PA6)
/MCU/ADC1_IN5: J1.6, U2.39 (PB1)
/MCU/ADC1_IN10: J1.5, U2.18 (PC0)
/MCU/ADC1_IN12: J1.8, U2.20 (PC2)
/MCU/ADC1_IN13: J1.7, U2.21 (PC3)
/MCU/ADC1_IN15: J1.10, U2.29 (PA3)
/MCU/DEBUG_SWCLK: J4.4, U2.96 (PA14(JTCK)
/MCU/DEBUG_SWDIO: J4.2, U2.95 (PA13(JTMS)
/MCU/ETH_MDC: J3.14, U2.19 (PC1)
/MCU/ETH_MDIO: J3.6, U2.28 (PA2)
/MCU/ETH_MII_RX_ER: J3.24, U2.73 (PB10)
/MCU/ETH_RMII_CRS_DV: J3.8, U2.35 (PA7)
/MCU/ETH_RMII_INTN: J3.20, U2.110 (PD4)
/MCU/ETH_RMII_REF_CLK: J3.4, U2.27 (PA1)
/MCU/ETH_RMII_RXD0: J3.16, U2.36 (PC4)
/MCU/ETH_RMII_RXD1: J3.18, U2.37 (PC5)
/MCU/ETH_RMII_TXD0: J3.10, U2.38 (PB0)
/MCU/ETH_RMII_TXD1: J3.12, U2.144 (PB7)
/MCU/ETH_RMII_TX_EN: J3.22, U2.74 (PB11)
/MCU/FDCAN2_RX: J2.9, U2.75 (PB12)
/MCU/FDCAN2_TX: J2.11, U2.76 (PB13)
/MCU/I2C2_SCL: J2.13, U2.90 (PA8), U7.18 (SCL)
/MCU/I2C2_SDA: J2.15, U2.91 (PA9), U7.17 (SDA)
/MCU/I2S3_CK: J2.12, U2.101 (PC10)
/MCU/I2S3_SDI: J2.18, U2.102 (PC11)
/MCU/I2S3_SDO: J2.16, U2.40 (PB2)
/MCU/I2S3_WS: J2.14, U2.97 (PA15(JTDI))
/MCU/LED0: R6.1, U2.106 (PD2)
/MCU/LED1: R7.1, U2.105 (PD1)
/MCU/LED2: R8.1, U2.104 (PD0)
/MCU/LPUART1_CTS: J2.8, U2.93 (PA11)
/MCU/LPUART1_RTS: J2.10, U2.94 (PA12)
/MCU/LPUART1_RX: J2.6, U2.92 (PA10)
/MCU/LPUART1_TX: J2.4, U2.143 (PB6)
/MCU/NRST: C19.2, D6.1 (K), J4.6, SW1.3 (K), SW1.4 (A), U2.15 (NRST)
/MCU/OSPI_CS: R2.1, U1.C2 (CS), U2.64 (PO0)
/MCU/OSPI_DQS: U1.C3 (DQS), U2.59 (PO2)
/MCU/OSPI_SCLK: U1.B2 (SCLK), U2.53 (PO4)
/MCU/OSPI_SIO0: U1.D3 (SIO0), U2.55 (PP0)
/MCU/OSPI_SIO1: U1.D2 (SIO1), U2.61 (PP1)
/MCU/OSPI_SIO2: U1.C4 (SIO2), U2.48 (PP2)
/MCU/OSPI_SIO3: U1.D4 (SIO3), U2.49 (PP3)
/MCU/OSPI_SIO4: U1.D5 (SIO4), U2.47 (PP4)
/MCU/OSPI_SIO5: U1.E3 (SIO5), U2.54 (PP5)
/MCU/OSPI_SIO6: U1.E2 (SIO6), U2.58 (PP6)
/MCU/OSPI_SIO7: U1.E1 (SIO7), U2.60 (PP7)
/MCU/SDMMC2_CK: J3.3, U2.130 (PD6)
/MCU/SDMMC2_CMD: J3.5, U2.131 (PD7)
/MCU/SDMMC2_D0: J3.7, U2.77 (PB14)
/MCU/SDMMC2_D1: J3.9, U2.78 (PB15)
/MCU/SDMMC2_D2: J3.11, U2.134 (PB3(JTDO)
/MCU/SDMMC2_D3: J3.13, U2.135 (PB4(NJTRST))
/MCU/SDMMC2_D4: J3.15, U2.1 (PB8)
/MCU/SDMMC2_D5: J3.17, U2.2 (PB9)
/MCU/SDMMC2_D6: J3.19, U2.84 (PC6)
/MCU/SDMMC2_D7: J3.21, U2.85 (PC7)
/MCU/UCPD_CC1: U2.111 (PM0), U7.1 (CC1)
/MCU/UCPD_CC2: U2.112 (PM1), U7.3 (CC2)
/MCU/UCPD_INT: U2.121 (PM8), U7.19 (FLG_n)
/MCU/UCPD_ISENSE: U2.33 (PA5), U7.4 (I_ANA)
/MCU/UCPD_PWR_EN: U2.122 (PM9), U7.20 (EN)
/MCU/USART3_CK: J2.7, U2.67 (PD10)
/MCU/USART3_RX: J2.5, U2.66 (PD9)
/MCU/USART3_TX: J2.3, U2.65 (PD8)
/MCU/USB_HS_D+: U2.119 (PM6), U9.6 (D+_ic)
/MCU/USB_HS_D-: U2.118 (PM5), U9.5 (D-_ic)
/MCU/USER_SW1: C37.2, SW2.3 (K), SW2.4 (A), U2.83 (PD15)
/MCU/USER_SW2: C38.2, SW3.3 (K), SW3.4 (A), U2.82 (PD14)
/USB/CC1: C70.1, J9.A5 (CC1), U7.15 (CC_1c)
/USB/CC2: C69.1, J9.B5 (CC2), U7.13 (CC_2c)
/USB/D+: J9.A6 (DP1), J9.B6 (DP2), U9.1 (D+_con)
/USB/D-: J9.A7 (DN1), J9.B7 (DN2), U9.2 (D-_con)
DVDD: C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, Q1.2 (C), U3.20 (DVDD), U3.35 (DVDD), U3.53 (DVDD), U3.71 (DVDD)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.1, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D7.1 (K), J1.9, J1.11, J1.12, J2.17, J2.19, J2.20, J3.23, J3.25, J3.26, J4.3, J4.5, J5.13, J5.14, J6.8, J7.2, J8.2, J9.A1_B12 (GND), J9.B1_A12 (GND), J9.S1 (SHIELD), J9.S2 (SHIELD), J9.S3 (SHIELD), J9.S4 (SHIELD), R1.1, R11.1, R17.1, R23.2, R24.2, SW1.1, SW1.2, SW2.1, SW2.2, SW3.1, SW3.2, SW4.3 (K), SW4.4 (A), U1.B3 (GND), U1.C1 (VSSQ), U1.E5 (VSSQ), U2.8 (VSS), U2.16 (VSS), U2.22 (VSSA), U2.23 (VREFM), U2.30 (VSS), U2.42 (VSS), U2.46 (VSS), U2.50 (VSS), U2.56 (VSS), U2.62 (VSS), U2.70 (VSS), U2.80 (VSS), U2.89 (VSS), U2.99 (VSS), U2.107 (VSS), U2.117 (VSSUSB), U2.132 (VSS), U2.138 (VSS), U3.1 (DGND), U3.6 (AGND), U3.14 (PGND), U3.17 (DGND), U3.19 (DGND), U3.25 (DGND), U3.36 (DGND), U3.37 (DGND), U3.54 (DGND), U3.55 (DGND), U3.72 (DGND), U3.73 (EP(GND)), U4.1 (GND), U5.2 (GND), U6.1 (GND), U7.12 (GND), U7.21 (GND), U8.2, U9.3 (GND), U9.4 (GND), X1.2 (GND), X2.2 (GND)
MCU_DVDD: C2.2, C32.2, C33.2, C35.2, C36.2, U2.43 (VCAP1), U2.79 (VCAP2), U2.98 (VCAP3), U2.120 (DVDD), U2.137 (VCAP4)
unnamed: C39.1, R12.1
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), J7.1
unnamed: D6.2 (A), U1.A4 (RESET)
unnamed: D7.2 (A), R26.2
unnamed: J6.2, R26.1
unnamed: Q1.1 (B), R10.2, U3.3 (VDRIVE)
unnamed: Q2.2 (G2), Q2.4 (G1), U7.7 (GDC_g)
unnamed: Q2.1 (S2), Q2.3 (S1), U7.8 (GDC_s)
unnamed: Q3.2 (G2), Q3.4 (G1), U7.5 (GDP_g)
unnamed: Q3.1 (S2), Q3.3 (S1), U7.6 (GDP_s)
unnamed: R3.2, U1.A5 (ECS)
unnamed: R1.2, U2.128 (BOOT0)
unnamed: R4.2, U2.13 (PH0)
unnamed: R13.2, U3.57 (BCLK_IN0)
unnamed: R14.2, U3.40 (BCLK_OUT0)
unnamed: R9.1, U3.23 (CLKOUT)
unnamed: R15.2, U3.58 (LRCLK_IN0/MP10)
unnamed: R16.2, U3.39 (LRCLK_OUT0/MP4)
unnamed: C40.2, R12.2, U3.16 (PLLFILT)
unnamed: R18.2, U3.59 (SDATA_IN0)
unnamed: R19.2, U3.41 (SDATA_OUT0)
unnamed: R11.2, U3.34 (SELFBOOT)
unnamed: C71.1, U7.14 (C_BIAS)
unnamed: R24.1, U7.16 (I2C_ADD)
unnamed: Q2.7 (D2), Q2.8 (D2), Q3.7 (D2), Q3.8 (D2), R21.1, U7.10 (I_SENSE)
unnamed: R22.2, R23.1, U7.11 (V_SENSE)
unnamed: R4.1, X1.3 (OUT)
unnamed: R20.1, X2.3 (OUT)
VBUS: C68.1, J9.A4_B9 (VBUS), J9.B4_A9 (VBUS), R21.2, R22.1, U7.9 (VBUS_c), U8.1

## Code that names these connections

File STM32CubeIDE/JUMBLEQ/JUMBLEQ.ioc (part):

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Mcu.Name=STM32H7S3Z8Tx
Mcu.Package=LQFP144
Mcu.UserName=STM32H7S3Z8Tx
PA0.GPIOParameters=PinAttribute
PA0.PinAttribute=Appli
PA0.Signal=ADCx_INP0
PA10.GPIOParameters=GPIO_Speed,PinAttribute
PA10.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA10.PinAttribute=Appli
PA10.Signal=S_TIM1_CH3
PA13(JTMS/SWDIO).Mode=Serial_Wire
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=Serial_Wire
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA3.GPIOParameters=PinAttribute
PA3.PinAttribute=Appli
PA3.Signal=ADCx_INP15
PA4.GPIOParameters=PinAttribute
PA4.Mode=IN18-Single-Ended
PA4.PinAttribute=Appli
PA4.Signal=ADC1_INP18
PA5.GPIOParameters=PinAttribute
PA5.Mode=IN18-Single-Ended
PA5.PinAttribute=Appli
PA5.Signal=ADC2_INP18
PA6.GPIOParameters=PinAttribute
PA6.PinAttribute=Appli
PA6.Signal=ADCx_INP3
PA8.GPIOParameters=PinAttribute
PA8.Mode=I2C
PA8.PinAttribute=Appli
PA8.Signal=I2C3_SCL
PA9.GPIOParameters=PinAttribute
PA9.Mode=I2C
PA9.PinAttribute=Appli
PA9.Signal=I2C3_SDA
PB1.GPIOParameters=PinAttribute
PB1.PinAttribute=Appli
PB1.Signal=ADCx_INP5
PB10.GPIOParameters=PinAttribute
PB10.Mode=I2C
PB10.PinAttribute=Appli
PB10.Signal=I2C2_SCL
PB11.GPIOParameters=PinAttribute
PB11.Mode=I2C
PB11.PinAttribute=Appli
PB11.Signal=I2C2_SDA
PB12.ContextOwner=Appli
PB12.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PB12.GPIO_Label=S3
PB12.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB12.PinAttribute=Appli
PB12.Signal=GPIO_Output
PB13.ContextOwner=Appli
PB13.GPIOParameters=PinState,GPIO_Label,PinAttribute
PB13.GPIO_Label=CODEC_RESET
PB13.PinAttribute=Appli
PB13.PinState=GPIO_PIN_SET
PB13.Signal=GPIO_Output
PC0.GPIOParameters=PinAttribute
PC0.PinAttribute=Appli
PC0.Signal=ADCx_INP10
PC2.GPIOParameters=PinAttribute
PC2.PinAttribute=Appli
PC2.Signal=ADCx_INP12
PC3.GPIOParameters=PinAttribute
PC3.PinAttribute=Appli
PC3.Signal=ADCx_INP13
PC9.GPIOParameters=PinAttribute
PC9.Mode=Audio_ClockIn
PC9.PinAttribute=Free
PC9.Signal=I2S_CKIN
PD0.ContextOwner=Appli
PD0.GPIOParameters=GPIO_Label,PinAttribute
PD0.GPIO_Label=LED2
PD0.PinAttribute=Appli
PD0.Signal=GPIO_Output
PD1.ContextOwner=Appli
PD1.GPIOParameters=GPIO_Label,PinAttribute
PD1.GPIO_Label=LED1
PD1.PinAttribute=Appli
PD1.Signal=GPIO_Output
PD10.ContextOwner=Appli
PD10.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PD10.GPIO_Label=S2
PD10.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD10.PinAttribute=Appli
PD10.Signal=GPIO_Output
PD11.GPIOParameters=GPIO_Speed,PinAttribute
PD11.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PD11.Mode=SAI_A_AsyncSlave
PD11.PinAttribute=Appli
PD11.Signal=SAI2_SD_A
PD12.GPIOParameters=GPIO_Speed,PinAttribute
PD12.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PD12.Mode=SAI_A_AsyncSlave
PD12.PinAttribute=Appli
PD12.Signal=SAI2_FS_A
PD13.GPIOParameters=GPIO_Speed,PinAttribute
PD13.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PD13.Mode=SAI_A_AsyncSlave
PD13.PinAttribute=Appli
PD13.Signal=SAI2_SCK_A
PD14.ContextOwner=Appli
PD14.GPIOParameters=GPIO_Label,PinAttribute
PD14.GPIO_Label=SW2
PD14.PinAttribute=Appli
PD14.Signal=GPIO_Input
PD15.ContextOwner=Appli
PD15.GPIOParameters=GPIO_Label,PinAttribute
PD15.GPIO_Label=SW1
PD15.PinAttribute=Appli
PD15.Signal=GPIO_Input
PD2.ContextOwner=Appli
PD2.GPIOParameters=GPIO_Label,PinAttribute
PD2.GPIO_Label=LED0
PD2.PinAttribute=Appli
PD2.Signal=GPIO_Output
PD8.ContextOwner=Appli
PD8.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PD8.GPIO_Label=S0
PD8.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD8.PinAttribute=Appli
PD8.Signal=GPIO_Output
PD9.ContextOwner=Appli
PD9.GPIOParameters=GPIO_Speed,GPIO_Label,PinAttribute
PD9.GPIO_Label=S1
PD9.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD9.PinAttribute=Appli
PD9.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Speed,PinAttribute
PE4.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE4.Mode=SAI_A_AsyncSlave
PE4.PinAttribute=Appli
PE4.Signal=SAI1_FS_A
PE5.GPIOParameters=GPIO_Speed,PinAttribute
PE5.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE5.Mode=SAI_A_AsyncSlave
PE5.PinAttribute=Appli
PE5.Signal=SAI1_SCK_A
PE6.GPIOParameters=GPIO_Speed,PinAttribute
PE6.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE6.Mode=SAI_A_AsyncSlave
PE6.PinAttribute=Appli
PE6.Signal=SAI1_SD_A
PH0-OSC_IN(PH0).Mode=HSE-DIG-External-Clock-Source
PH0-OSC_IN(PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT(PH1).ContextOwner=Appli
PH1-OSC_OUT(PH1).GPIOParameters=PinState,GPIO_Label,PinAttribute
PH1-OSC_OUT(PH1).GPIO_Label=DSP_RESET
PH1-OSC_OUT(PH1).PinAttribute=Appli
PH1-OSC_OUT(PH1).PinState=GPIO_PIN_SET
PH1-OSC_OUT(PH1).Signal=GPIO_Output
RCC.SYSCLKFreq_VALUE=600000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-01-30 RHPORT1がUSB HSなのに0を定義してたので修正
2026-01-30 フォーマット修正
2026-01-30 FreeRTOSのヒープを通常RAMに配置
2026-02-06 .ioc更新とコード再生成
    USE_NEWLIB_REENTRANTを有効化
    VBUSセンス用のIO設定を追加
2026-02-06 非キャッシュ領域の範囲を修正
2026-02-07 入力chをどちらもLINE入力にする
2026-02-07 BootとExtMemLoaderのXSPI設定を見直し（STのサンプルコードに合わせる）
2026-02-07 OLED描画のsprintfをsnprintfに変更
2026-02-07 実際のフラッシュサイズに合わせて修正
2026-02-07 範囲修正
2026-02-09 XSPIのパラメータ変更
2026-02-09 不要になったデバッグ変数を削除
2026-02-09 アプリコードでもMPU設定を明示的に行う（Bootと同じ）。
    DWTの初期化も行う（デバッグで時間計測を行うとき用）
2026-02-10 Errata 2.2.15への対処コードを追加
2026-02-10 2枚目のOLED用にi2c2を有効化
2026-02-10 OLEDを2枚運用できるように改良
2026-02-10 OLED2枚運用に対応
2026-02-10 CubeMXでコード再生成したときに消えないようにする
2026-02-10 レイテンシー改善
2026-02-12 外形寸法を記入
2026-02-12 FlexASIO用の設定ファイルを削除
2026-02-12 UF2ブートローダーを実装
    Releaseビルドしないとbootflashに入りきらない
2026-02-12 TCPP03のFLG_nとENの簡易制御を実装
    I_senseをA/Dで監視できるようにIO設定をしておく
2026-02-12 HAL_DelayをosDelayに変更
2026-02-12 tud_audio_read_lockedを削除し、シンプルにtud_audio_readを呼ぶ
2026-02-12 サンプルレート切り替え時のAK4619再初期化時のI2C排他漏れを修正
2026-02-13 SAIのリングバッファサイズ調整
2026-02-13 リング水位によって消費するフレーム数を調整
2026-02-13 OLEDの再描画を差分更新に変更。
2026-02-13 フィードバックEPを実装
2026-02-13 SPIデバッグ用の変数を用意
2026-02-13 USBタスクの優先度をRealtimeにする。
    デバッグ用の変数を用意
2026-02-13 Update README to reflect changes in prototype and pinout
    Removed images related to Prototype 1 and Main board, added Pinout section with image.
2026-02-13 Add image gallery for prototypes and main board
2026-02-13 オーディオ処理でバッグ用の変数を用意
2026-02-13 サンプルレート更新用の関数を初期化関数と別にする
2026-02-13 オーディオのレイテンシー短縮
2026-02-13 電源投入時にOLEDが描画されない不具合を修正
2026-02-13 サンプルレート切り替えを繰り返すと無音化する不具合に対応
2026-02-13 ADCのオーバーサンプリングを有効化し、コード上の移動平均幅を縮小
2026-02-13 ADC初期化関数をADCタスク内に移動
2026-02-13 部品値を修正
2026-02-15 AK4169のADC1/2のボリュームを+12dBに変更
2026-02-16 Reorganize gallery sections and add images
2026-02-16 Add firmware update section to README
    Added firmware update instructions for JUMBLEQ, detailing the UF2 bootloader and update process.
2026-02-16 XF assign切り替え時にOLED表示も更新
2026-02-17 サブOLEDの描画用関数名を修正
2026-02-17 XF assignをサブOLEDに描画する
2026-02-17 XF assignの初期値修正
2026-02-17 サブOLEDを差分描画に変更
2026-02-17 LEDの更新周期を5msに変更
2026-02-17 再描画時にクリアする領域を分割する
2026-02-18 THRU列のクリア処理を修正
2026-02-18 入力タイプを切り替えたときに正しく描画されるよう修正
2026-02-18 MIDI program changeで、XF assignとinput typeの切り替えを出来るようにする
2026-02-18 メインOLEDの表示を見やすく調整
2026-02-18 ヘルパー関数を作ってOLED_UpdateTask内部の処理をリファクタリング
2026-02-18 不要になった処理を削除
2026-02-18 Gain（Ch.1、Ch.2、Mst）とDry/Wetの表示レンジを修正
2026-02-18 MIDI受信処理をリファクタリング
2026-02-18 double値を8.24形式の固定小数点に変換する関数を修正
2026-02-18 AK4619の入力ゲインを0dBに戻す
2026-02-18 未使用の変数と関数を削除
2026-02-18 未使用のenumを削除
2026-02-18 ui_control_task()内の処理を機能毎に関数化して整理
2026-02-18 POTと磁気スイッチの処理をリファクタリング
2026-02-18 MIDI受信処理をSwitch文からコマンドテーブル化
2026-02-18 磁気スイッチのアナログ値に対する移動平均処理を削除
2026-02-18 グローバル変数を構造体にまとめる
2026-02-18 audio_control.c/.hからUI処理群を別コードに移す。
2026-02-18 マジックナンバーを定数化
2026-02-18 リファクタリング
2026-02-18 SigmaStudio+のプロジェクト名を修正
2026-02-18 osDelayのWarning解消
2026-02-18 UAC1用の記述、コードを削除。
2026-02-18 ビット深度16bitの処理を削除（未サポートのため）
2026-02-19 外付けのEEPROMにパラメータを保存、起動時に読み出す機能を実装
2026-02-19 ProgramChangeのプログラムナンバー127のボタンを追加
2026-02-19 デバイス初期化中にOLEDにメッセージ表示
2026-02-19 Revise README to add modules section
    Updated the README to include a new section for modules, categorizing original and third-party modules.
2026-02-19 Update block diagram in README
    Replaced the block diagram image with a new diagram.
2026-02-19 AK4619初期化時にDACの音量を明示的に設定
2026-02-20 オーバーフローの回避処理がフレーム境界に揃っていない不具合を修正
2026-02-20 ホスト側でオーディオ入力名が「JUMBLEQ Stereo IN」となるように修正
    USB Audio Functionを2つに分離（OUT専用とIN専用）
2026-02-20 POT数を8から12に、磁気スイッチを6から10に変更
2026-02-20 djayのDVSに対応するためのルーティングを追加
2026-02-21 djayのDVSを使用するための設定切り替え関数等を用意
2026-02-21 DMAのバッファサイズを半分にしてレイテンシー改善
2026-02-22 AudioTaskを通知駆動+1msタイムアウトのハイブリッド処理に変更
2026-02-22 THRU設定でもUSB[3/4]を選択出来るようにする
2026-02-22 ホストに表示される入出力名を修正
2026-02-25 XF assignでUSB[3/4]を切り替えられるようにumenu修正
2026-02-25 【アプリコード】CubeIDE、CubeMX更新に伴うコード再生成
2026-02-25 【Boot/ExtLoader】CubeIDE、CubeMX更新に伴うコード再生成
2026-02-25 【Boot】ビルド時のエラーと警告を出ないように修正
2026-02-25 【Appli】設定起因のビルドエラーが出ないようにする
2026-02-25 【ExtMemLoader】ビルド時の警告を出ないようにする
2026-02-25 【ExtMemLoader】生成した.stldrが正しく動作するように修正
2026-02-26 DVS設定の有効無効をサブOLEDで確認出来るようにする
2026-02-26 sprintfが使えるようにstdio.hをインクルードする
2026-02-26 【Max】DVS設定の切り替えに対応
2026-02-26 ビルド設定が書き換わったかどうか確認するPowerShellスクリプトを追加
2026-02-26 FWバージョン番号を管理しやすくする
2026-02-26 サブOLEDの初期表示のチラつきを修正
2026-02-27 メインOLEDを3行表示にし、3行目に中央の磁気スイッチの状態を表示する
